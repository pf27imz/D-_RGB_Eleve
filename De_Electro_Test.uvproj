# Keil uVision project De_Electro_Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F300 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: De_Electro_Test
  c flags: SizeSpeed=1
  group Source Group 1
    ./: De_Electro_Test.c
